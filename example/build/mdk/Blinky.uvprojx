# Keil uVision project Blinky.uvprojx, settings and files
target V2M-MPS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: __USE_FPGA __USER_DEFINED_APP_CFG_H__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group Source Files
    ../../: system.c app_cfg.h
  group Documentation
    ./: Abstract.txt
  group gmsi
    ../../../sources/gmsi/utilities/: ooc.c
    ../../../sources/gmsi/utilities/arm/: signal.c
    ../../../sources/gmsi/: gmsi.c
    ../../../sources/gmsi/hal/bsp/: bsp.c
    ../../../sources/gmsi/hal/: hal.c
    ../../../sources/gmsi/hal/component/: component.c
    ../../../sources/gmsi/hal/component/bootloader/: bootloader.c
    ../../../sources/gmsi/hal/component/key/: key.c
    ../../../sources/gmsi/hal/component/key/key_queue/: key_queue.c
    ../../../sources/gmsi/hal/component/memory/mal/: mal.c
    ../../../sources/gmsi/hal/component/memory/mal/sdf_w25qxxx/: sdf_w25qxxx.c
    ../../../sources/gmsi/hal/component/memory/mal/sram/: sram.c
    ../../../sources/gmsi/hal/component/memory/page/: page.c
    ../../../sources/gmsi/hal/component/sw_sdio/: sw_sdio.c
    ../../../sources/gmsi/service/communication/crc/: crc.c crc7.c crc8.c crc16.c crc32.c
    ../../../sources/gmsi/service/communication/frame/es_simple_frame/: es_simple_frame.c
    ../../../sources/gmsi/service/communication/xmodem/: xmodem.c
    ../../../sources/gmsi/service/encryption/random/: random.c
    ../../../sources/gmsi/service/memory/: memory.c
    ../../../sources/gmsi/service/memory/epool/: epool.c
    ../../../sources/gmsi/service/scheduler/: scheduler.c shell.c task.c
    ../../../sources/gmsi/service/: service.c
    ../../../sources/gmsi/service/memory/stream2block/: stream2block.c stream2block.h
    ../../../sources/: environment_cfg.h app_cfg.h
    ../../../sources/gmsi/utilities/template/: t_list.c t_list.h t_pool.h t_queue.h template.h
    ../../../sources/gmsi/service/communication/telegraph_engine/: telegraph_engine.c telegraph_engine.h
    ../../../sources/gmsi/service/time/: time.c time.h
    ../../../sources/gmsi/service/time/multiple_delay/: multiple_delay.c multiple_delay.h
    ../../../sources/gmsi/service/memory/block_queue/: block_queue.c block_queue.h
    ../../../sources/gmsi/service/memory/block/: block.c block.h
    ../../../: README.md
  group app_platform
    ../../app_platform/: app_platform.h app_platform.c stdout_USART.c stdout_USART.h
target FRDM-K64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: __USER_DEFINED_APP_CFG_H__ DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM
  c misc: --diag_suppress=66,1296,186 --library_type=standardlib --library_interface=armcc
  c include: ..;../../../../../../CMSIS/Driver/Include;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/cmsis_drivers;../../../../../../devices/MK64F12/utilities/io;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/log;../../../../../../devices/MK64F12/utilities;../../../../../../devices/MK64F12
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0xxx12\MK64FN1M0xxx12_flash.scf
software components: CMSIS:CORE 5.0.2, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0.0, Device:Startup 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:dmamux 2.0.2, Device:SDK Drivers:edma 2.1.2, Device:SDK Drivers:flash 2.4.1, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:port 2.0.2, Device:SDK Drivers:smc 2.0.3, Device:SDK Drivers:uart 2.1.5, Device:SDK Project Template:RTE_Device 1.0.0, Device:Startup 1.0.0
